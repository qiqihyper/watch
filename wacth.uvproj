# Keil uVision project wacth.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: wacth +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: wacth.c delay.h
  group 资料
    ./资料/: _1602 _1602_delay_h _shuma7281_1 _shuma7281
    ./: jianpan
